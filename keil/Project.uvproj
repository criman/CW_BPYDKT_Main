# Keil uVision project Project.uvproj, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ES8H0183 ES
  cpu: IRAM(0x20000000-0x20003FFF)  IROM(0x00000000-0x0001FFFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: CW_BPYDKT_ES8H0183_V +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\code\_CMSIS;..\code\_mdev;..\code\_msys;..\library\Device\ES8H018x\Include;..\library\StdDriver\inc;..\code\Module\Module_EEP24C02_V1.0.0;..\code\Module\Module_Ad_ES8H018X_V1.0.0;..\code\Module\Module_Switch_V1.0.0;..\code\Module\Module_Stepmotor_V1.0.0;..\code\Module\Module32_Uart_V1.0.0;..\code\Function;..\code\mcu_sdk;..\code\SEGGER_RTT
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MCU
    ../library/Device/ES8H018x/Include/: es8h018x.h
    ../library/Device/ES8H018x/: startup_ES8H018x.s
  group LIB
    ../library/StdDriver/src/: lib_adc.c lib_crc.c lib_gpio.c lib_iap.c lib_iic.c lib_printf.c lib_scs.c lib_scu.c lib_spi.c lib_timer.c lib_uart.c lib_wdt.c
  group User
    ../code/_mdev/: irqhandler.c systick.c Init_ES8H018X_EX8H0163.c
    ../code/_CMSIS/: system_es8h018x.c
    ../code/_msys/: Func.c main.c
  group Module
    ../code/Module/Module_EEP24C02_V1.0.0/: EEP24C02.c
    ../code/Module/Module_Ad_ES8H018X_V1.0.0/: Ad.c Ad_app.c
    ../code/Module/Module_Switch_V1.0.0/: Switch.c
    ../code/Module/Module_Stepmotor_V1.0.0/: Stepmotor.c Stepmotor_app.c Swing.c
    ../code/Module/Module32_Uart_V1.0.0/: Uart.c Uart_app.c
  group Function
    ../code/Function/: Function.c Remember.c Protect.c Defrost.c CommMotDrv.c CommDisp.c CmdIn.c CmdOut.c Comp.c Fan.c Timer.c Tempr.c WaterBox.c FourWay.c WPMotor.c UVC.c ExpValve.c LowPower.c EAHeater.c DCFan.c tWiFi.c
  group mcu_sdk
    ../code/mcu_sdk/: mcu_api.c protocol.c system.c
  group RTT
    ../code/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_Demo.c SEGGER_RTT_printf.c
